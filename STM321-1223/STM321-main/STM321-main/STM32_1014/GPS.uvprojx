# Keil uVision project GPS.uvprojx, settings and files
target GPS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F205VE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.1.0.7
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: GRCGPSV6N +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\GRCGPSV6N.axf --output GRCGPSV6N.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,  HSE_VALUE=8000000
  c include: .\inc;.\inc\BGT;.\inc\GPS;.\inc\GSM;.\src\Memories;.\inc\MaHoa;.\inc\Taxi;.\inc\AmThanh
  asm define: NO_CRP
  memory RVCT4: ROM 0x8000000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./src/: main.c InitSystem.c Interrup.c flash.c TIM.c UART.c RTC.c Structure_Data.c debug.c Data.c LED.c Flash_internal.c Camera.c SPIFFS.c
  group GPS
    ./src/: GPS_Process.c MC60_GPS.c
  group GSM
    ./src/: GSM_GPRS.c GSM_Process.c MC60_GSM.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 1.1.0, Device:StdPeriph Drivers:EXTI 1.1.0, Device:StdPeriph Drivers:Flash 1.1.0, Device:StdPeriph Drivers:Framework 1.1.1, Device:StdPeriph Drivers:GPIO 1.1.0, Device:StdPeriph Drivers:IWDG 1.1.0, Device:StdPeriph Drivers:PWR 1.1.0, Device:StdPeriph Drivers:RCC 1.1.0, Device:StdPeriph Drivers:RTC 1.1.0, Device:StdPeriph Drivers:SPI 1.1.0, Device:StdPeriph Drivers:SYSCFG 1.1.0, Device:StdPeriph Drivers:TIM 1.1.0, Device:StdPeriph Drivers:USART 1.1.0
